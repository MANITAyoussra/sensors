# Keil uVision project IO_Toggle.uvprojx, settings and files
target IO_Toggle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IO_Toggle +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\OOLayer_Lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../: main.cpp stm32_wrapper_gpio.c stm32f4xx_hal_gpio.c
  group STM32F4xx_StdPeriph_Driver
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../: startup_stm32f401xe.s
software components: CMSIS:CORE 5.1.2
